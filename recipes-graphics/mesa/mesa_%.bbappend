PACKAGECONFIG_append_tx6 = " etnaviv kmsro opengl egl gles gbm dri gallium"
