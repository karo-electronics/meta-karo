inherit relative_symlinks
