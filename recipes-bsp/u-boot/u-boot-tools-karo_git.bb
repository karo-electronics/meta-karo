require u-boot-karo-common_git.inc
require u-boot-tools-karo_git.inc
