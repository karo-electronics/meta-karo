require u-boot-karo-common_git.inc
require u-boot-fw-utils-karo_git.inc
