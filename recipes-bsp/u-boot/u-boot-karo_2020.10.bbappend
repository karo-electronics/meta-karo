SRC_URI:append = " \
    file://karo.bmp;subdir=git/tools/logos \
"

SRC_URI:append = " \
    file://dts/r9a07g044l2-qsrz.dtsi;subdir=git/arch/arm \
    file://dts/r9a07g044l2-qsrz-qsbase1.dtsi;subdir=git/arch/arm \
    file://dts/r9a07g044l2-qsrz-qsbase4.dtsi;subdir=git/arch/arm \
    file://dts/r9a07g044l2-txrz.dtsi;subdir=git/arch/arm \
"
