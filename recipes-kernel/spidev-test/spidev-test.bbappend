PACKAGE_DEBUG_SPLIT_STYLE = "debug-without-src"
